FILESEXTRAPATHS:prepend:${MACHINE} := "${THISDIR}/${PN}:"

SRC_URI += "file://${MACHINE}.cfg"

OBMC_IMAGE_EXTRA_INSTALL:append:palmetto = " mboxd"
IMAGE_INSTALL:append = " hello-simon"

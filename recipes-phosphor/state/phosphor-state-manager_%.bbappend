FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-phosphor-state-manager-update-bmc-state-manager-beha.patch"

